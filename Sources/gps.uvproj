# Keil uVision project gps.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: gps +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\GPS 3.0
  asm include: ..\GPS 3.0
  group Source Group 1
    ./: gps.uvproj.c lcd1602.c uart.c delay.c
